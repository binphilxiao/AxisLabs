<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\FR2000_Quad_Encoder.ewp</path>
    </project>
    <batchBuild />
</workspace>
